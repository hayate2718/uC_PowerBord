# Repository hayate2718/uC_PowerBord

File README.md:

# uC_PowerBord
## マイコン用の電源ボード
1. 3s直接出力、5V出力
2. 逆接続防止回路、電源電圧監視3段階表示、UVLO搭載
3. UVLOは12V以上のとき電源が入り、11V以下で電源がオフになる

## EAGLE design uC_power/uC_power.brd

Parts:
C1: 22u; C1608
C2: 10u; C1608
C3, C8: 100u; 153CLV-0605
C4, C5, C6, C7, C9: 0.1u; C1608
C10: C-EUC1608; C1608
F1: RGEF300
GYAKUSETU_FET: FDS4935A; SOP8
IC1: MURATA_OKL-T/6-W12N-C; OKL-T/6-W12N-C
IC3: UPC339GR; TSSOP14
JP1, JP2, JP3: PINHD-1X2; 1X02
LED1, LED2: 1608LED; 1608
R1, R14: 1k; 1608
R2: 330; 1608
R3: 10; 1608
R4, R5, R6, R7, R8, R9, R10, R11, R12, R15, R16: 10k; 1608
R13: 470k; 1608
R17: 15k; 1608
R18: 22k; 1608
R_I1, R_I3: R_SHUGOU2; 1005X4RESISTOR
SW1: TOGURUSUIITI
SW_FET: FDS4935A; SOP8
TRIM_R1, TRIM_R2: 22k; PV23A
U$1, U$2, U$9: NJM2380; SOT23-5
U$3, U$4, U$5: SOT23_NFET; SOT23
U$6: RGB_LED
U$7, U$8: SMD_DAIOD; SOD_123
U$10: YUROBLOCK3
U$11: YUROBLOCK2

Connections:
COMP1: IC3.2 (2_OUT1), R5.1, U$5.PIN1 (PIN1_G)
COMP2: IC3.1 (1_OUT2), U$7.K (C)
COMP3: IC3.14 (14_OUT3), U$8.K (C)
COMP4: IC3.13 (13_OUT4), R9.1, U$3.PIN1 (PIN1_G)
GND: C1.1, C2.1, C3.-, C4.2, C5.2, C6.2, C7.2, C8.-, C9.2, C10.2, GYAKUSETU_FET.PIN2 (2_G2), GYAKUSETU_FET.PIN4 (4_G1), IC1.PIN1 (PIN1_ON/OFF), IC1.PIN3 (PIN3_GND), IC1.PIN3@2 (PIN3_GND), IC1.PIN7 (PIN7_GND), IC3.12 (12_V-), JP1.2, JP2.2, LED1.K, LED2.K, R3.1, R4.1, R8.1, R11.1, R16.1, R_I3.4, U$1.2 (PIN2_A), U$2.2 (PIN2_A), U$3.PIN2 (PIN3_S), U$4.PIN2 (PIN3_S), U$5.PIN2 (PIN3_S), U$9.2 (PIN2_A), U$10.P$3, U$11.P$2
G_SW: R10.1, U$4.PIN1 (PIN1_G), U$7.A, U$8.A
unnamed: R2.1, R3.2
unnamed: R1.1, R2.2
unnamed: IC1.PIN6 (PIN6_TRIM), R1.2
unnamed: R12.1, SW1.1, SW_FET.PIN2 (2_G2), SW_FET.PIN4 (4_G1)
unnamed: C5.1, IC3.4 (4_IN1-), IC3.7 (7_IN2+), JP1.1, R7.2, TRIM_R1.1 (E), U$1.4 (PIN4_C)
unnamed: C10.1, JP3.2, U$9.4 (PIN4_C)
unnamed: LED1.A, R14.1
unnamed: R13.1, R16.2, R18.1, U$9.5 (PIN5_REF)
unnamed: U$3.PIN3 (PIN2_D), U$6.R_K
unnamed: U$4.PIN3 (PIN2_D), U$6.G_K
unnamed: U$5.PIN3 (PIN2_D), U$6.B_K
unnamed: R_I1.4, U$6.B_A
unnamed: R_I1.3, U$6.G_A
unnamed: R_I1.2, U$6.R_A
unnamed: R8.2, TRIM_R1.2 (A), TRIM_R1.3 (S), U$1.5 (PIN5_REF)
unnamed: R11.2, TRIM_R2.2 (A), TRIM_R2.3 (S), U$2.5 (PIN5_REF)
unnamed: R17.1, R18.2
unnamed: LED2.A, R15.1
unnamed: C6.1, IC3.8 (8_IN3-), IC3.11 (11_IN4+), JP2.1, R6.1, TRIM_R2.1 (E), U$2.4 (PIN4_C)
unnamed: JP3.1, SW1.2, SW1.C
unnamed: F1.P$2, U$11.P$1
unnamed: IC3.5 (5_IN1+), IC3.6 (5_IN2-), IC3.9 (9_IN3+), IC3.10 (10_IN4-), R_I3.5, R_I3.8
V5: C2.2, C3.+, C4.1, IC1.PIN4 (PIN4_VOUT), IC1.PIN5 (PIN5_SENSE), R14.2, U$10.P$2
V12: C1.2, IC1.PIN2 (PIN2_VIN), IC1.PIN2@2 (PIN2_VIN), IC1.PIN9 (PIN9_SEQUENCE), R4.2, R13.2, R15.2, SW_FET.PIN5 (5_D1), SW_FET.PIN6 (6_D1), SW_FET.PIN7 (7_D2), SW_FET.PIN8 (8_D2), U$10.P$1
VCC: C8.+, C9.1, F1.P$1, GYAKUSETU_FET.PIN5 (5_D1), GYAKUSETU_FET.PIN6 (6_D1), GYAKUSETU_FET.PIN7 (7_D2), GYAKUSETU_FET.PIN8 (8_D2)
V_SENS: C7.1, GYAKUSETU_FET.PIN1 (1_S2), GYAKUSETU_FET.PIN3 (3_S1), IC3.3 (3_V+), R5.2, R6.2, R7.1, R9.2, R10.2, R12.2, R17.2, R_I1.5, R_I1.6, R_I1.7, R_I1.8, R_I3.1, SW_FET.PIN1 (1_S2), SW_FET.PIN3 (3_S1)

Notes on the sheet:
5.5Vに設定
5,75Vに設定
緊急停止スイッチをつなぐピンヘッダ

Board: 2 copper layers, 49.5 x 37.8 mm, 54 parts (28 on the bottom side), 32 nets.

## Commit log

2020-12-03 uvloを取っ払った
    uvloを付けたのはいいけど調節がめんどくさいことに気が付いた
2020-12-05 UVLO、リセッタブルヒューズを追加
    安全な自動シャットダウンのためのuvloを追加、ショート時の保護のためのリセッタブルヒューズを追加
